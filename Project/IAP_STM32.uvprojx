# Keil uVision project IAP_STM32.uvprojx, settings and files
target ARM32 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: IAP_Bootloader +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER,__STRICT_ANSI__
  c include: ..\App_Common;..\Drv_Common;..\Libraries;..\Libraries\FWlib\inc;..\Arm
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group App_Common
    ./: main.c
    ../App_Common/: update.c
  group Drv_Common
    ../Drv_Common/: led_drv.c systick_drv.c delay.c rs485_drv.c inflash_drv.c
  group FWLB
    ../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group ARM_Kernel
    ../Arm/: startup_stm32f10x_hd.s system_stm32f10x.c core_cm3.c
